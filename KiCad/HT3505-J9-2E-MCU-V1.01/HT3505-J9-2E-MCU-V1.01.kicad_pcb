# Repository FlyyingPiggy2020/HT3505-J9-2E

## KiCad design KiCad/HT3505-J9-2E-MCU-V1.01/HT3505-J9-2E-MCU-V1.01.kicad_pcb

Parts:
C1, C10, C18: 100nF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C2, C3, C11, C12: 100nF/25V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C4, C7: 1nF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C5, C8, C13: 1uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C6, C9, C14: 4.7uF/50V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C15, C17: 33pF/25V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C16: 10nF/50V; C_0603_1608Metric
C19: 47nF/50V; C_0603_1608Metric
C20: 1uF/50V; C_0603_1608Metric
C21: 22uF/10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C22, C25, C30: 100nF/10V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C23: 4.7uF/50V; C_0603_1608Metric
C24: 2.2uF/10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C26: 0.1UF/16V; C_0603_1608Metric
C27: 4.7uF/10V; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C28: 1uF/50V; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
C29: 100nF/50v; C_0402_1005Metric_Pad0.74x0.62mm_HandSolder
D1: DSK36; D_SOD-123
J1: A; WirePad_1P_1.5x1.5mm_NoPaste
J2: B; WirePad_1P_1.5x1.5mm_NoPaste
J3: C; WirePad_1P_1.5x1.5mm_NoPaste
J4: A; WirePad_1P_2.0x2.0mm_NoPaste
J5: B; WirePad_1P_2.0x2.0mm_NoPaste
J6: Conn_01x05; SWD_Pads_1x05_P1.27mm_0.8x1.5mm_NoPaste
J7: J1; ZX_SH1.0_3PWT_1x03_P1.00mm_Horizontal
L1: PCT322520-220-M/22uH; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
Q1, Q2, Q3, Q4, Q5, Q6: IRL60HS118; DFN-6-2EP_2x2mm_P0.65mm_EP1.15x0.95mm_EP0.8x0.48mm
R1, R2, R5, R6: 10Ω/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R3, R7: 12mΩ/750mW; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R4, R9, R11, R13: 10KΩ/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R8, R16: 10KΩ; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R10, R14: 100KΩ/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R12: 54.9KΩ/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R15: 120Ω/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R17: 10K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R18, R19, R21, R22: NC; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R20: 18KΩ/1%; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
R23: 75K; R_0402_1005Metric_Pad0.72x0.64mm_HandSolder
U1, U3: MT6701QT; QFN-16-1EP_3x3mm_P0.5mm_EP1.7x1.7mm
U2: GD32F303CCT6; LQFP-48_7x7mm_P0.5mm
U4: TJA1042T-3; SOIC-8_3.9x4.9mm_P1.27mm
U5: TLV75533PDRV; WSON-6-1EP_2x2mm_P0.65mm_EP1x1.6mm
U6: DRV8323RHRGZR; QFN-48_EP_7.4x7.4_Pitch0.5mm
X1: XL2EL89CSI-KPIYLC-8M; Crystal_SMD_3225-4Pin_3.2x2.5mm

Connections:
+3.3V: C1.1, C2.2, C3.2, C10.1, C11.2, C12.2, C22.2, C27.1, C29.1, J6.4, R4.2, R9.2, R16.2, R18.1, R19.2, R21.2, U1.13 (VDD), U1.14 (MODE), U2.1 (VBAT), U2.9 (VDDA), U2.24 (VDD_1), U2.36 (VDD_2), U2.48 (VDD_3), U3.13 (VDD), U3.14 (MODE), U4.5 (VIO), U5.1 (OUT), U6.26 (VREF)
+5V: C21.1, C24.1, C25.2, L1.1, R12.1, U4.3 (VCC), U5.4 (EN), U5.6 (IN)
/ADC_BUS_V: C16.2, R10.2, R11.1, U2.12 (PA2)
/ADC_PHASE_A: U2.10 (PA0/WKUP), U6.25 (SOA)
/ADC_PHASE_B: U2.11 (PA1), U6.24 (SOB)
/CAL: U2.41 (PB5), U6.34 (CAL)
/CAN0_RX: U2.32 (PA11/CAN0_RX), U4.4 (RXD)
/CAN0_TX: U2.33 (PA12/CAN0_TX), U4.1 (TXD)
/CANH: J7.1, R15.1, U4.7 (CANH)
/CANL: J7.2, R15.2, U4.6 (CANL)
/DRV_EN: R17.2, U2.43 (PB7), U6.33 (ENABLE)
/ENC_MOTOR_CLK: U1.7 (B), U2.15 (PA5)
/ENC_MOTOR_CS: R4.1, U1.8 (Z), U2.14 (PA4)
/ENC_MOTOR_DO: U1.6 (A), U2.16 (PA6)
/ENC_OUT_CLK: U2.39 (PB3/JTDO), U3.7 (B)
/ENC_OUT_CS: R9.1, U2.18 (PB0), U3.8 (Z)
/ENC_OUT_DO: U2.40 (PB4/NJTRST), U3.6 (A)
/GHA: Q1.3 (G), U6.8 (GHA)
/GHB: Q3.3 (G), U6.17 (GHB)
/GHC: Q5.3 (G), U6.18 (GHC)
/GLA: Q2.3 (G), U6.10 (GLA)
/GLB: Q4.3 (G), U6.15 (GLB)
/GLC: Q6.3 (G), U6.20 (GLC)
/NRST: C30.2, J6.3, U2.7 (NRST)
/OSCIN: C15.1, U2.5 (OSCIN), X1.1
/OSCOUT: C17.1, U2.6 (OSCOUT), X1.3
/SHA: J1.1 (Pin_1_1), Q1.4 (S), Q1.7 (S), Q2.1 (D), Q2.2 (D), Q2.5 (D), Q2.6 (D), Q2.8 (D), U6.9 (SHA)
/SHB: J2.1 (Pin_1_1), Q3.4 (S), Q3.7 (S), Q4.1 (D), Q4.2 (D), Q4.5 (D), Q4.6 (D), Q4.8 (D), U6.16 (SHB)
/SHC: J3.1 (Pin_1_1), Q5.4 (S), Q5.7 (S), Q6.1 (D), Q6.2 (D), Q6.5 (D), Q6.6 (D), Q6.8 (D), U6.19 (SHC)
/SNA: C4.2, R2.1, U6.12 (SNA)
/SNB: C7.2, R6.1, U6.13 (SNB)
/SPA: C4.1, R1.1, U6.11 (SPA)
/SPB: C7.1, R5.1, U6.14 (SPB)
/SWCLK: J6.2, U2.37 (PA14/SWCLK)
/SWDIO: J6.1, U2.34 (PA13/SWDIO)
/TIMER0_CH0: U2.29 (PA8), U6.37 (INHA)
/TIMER0_CH0_ON: U2.26 (PB13), U6.38 (INLA)
/TIMER0_CH1: U2.30 (PA9/USART0_TX), U6.39 (INHB)
/TIMER0_CH1_ON: U2.27 (PB14), U6.40 (INLB)
/TIMER0_CH2: U2.31 (PA10/USART0_RX), U6.41 (INHC)
/TIMER0_CH2_ON: U2.28 (PB15), U6.42 (INLC)
/VM: C5.1, C6.1, C8.1, C9.1, C13.1, C14.1, C18.1, C20.2, C23.1, J4.1 (Pin_1_1), Q1.1 (D), Q1.2 (D), Q1.5 (D), Q1.6 (D), Q1.8 (D), Q3.1 (D), Q3.2 (D), Q3.5 (D), Q3.6 (D), Q3.8 (D), Q5.1 (D), Q5.2 (D), Q5.5 (D), Q5.6 (D), Q5.8 (D), R10.1, R14.1, U6.6 (VM), U6.7 (VDRAIN), U6.47 (VIN)
/nFAULT: R16.1, U2.42 (PB6), U6.28 (nFAULT)
GND: C1.2, C2.1, C3.1, C5.2, C6.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, C21.2, C22.1, C23.2, C24.2, C25.1, C27.2, C28.1, C29.2, C30.1, D1.2 (A), J5.1 (Pin_1_1), J6.5, J7.3, Q6.4 (S), Q6.7 (S), R2.2, R3.2, R6.2, R7.2, R8.2, R11.2, R13.2, R17.1, R20.2, R22.2, R23.2, U1.16 (GND), U1.17 (GND), U2.8 (VSSA), U2.23 (VSS_1), U2.35 (VSS_2), U2.47 (VSS_3), U3.16 (GND), U3.17 (GND), U4.2 (GND), U4.8 (STB), U5.3 (GND), U5.7 (GND), U6.2 (PGND), U6.21 (SPC), U6.22 (SNC), U6.27 (DGND), U6.29 (MODE), U6.35 (AGND), U6.43 (BGND), U6.49 (EP), X1.2, X1.4
unnamed: C26.1, D1.1 (K), L1.2, U6.45 (SW)
unnamed: Q2.4 (S), Q2.7 (S), R1.2, R3.1
unnamed: Q4.4 (S), Q4.7 (S), R5.2, R7.1
unnamed: R8.1, U2.44 (BOOT0)
unnamed: C26.2, U6.44 (CB)
unnamed: C19.2, U6.4 (CPH)
unnamed: C19.1, U6.3 (CPL)
unnamed: C28.2, U6.36 (DVDD)
unnamed: R12.2, R13.1, U6.1 (FB)
unnamed: R18.2, R22.1, U6.32 (GAIN)
unnamed: R20.1, R21.1, U6.30 (IDRIVE)
unnamed: C20.1, U6.5 (VCP)
unnamed: R19.1, R23.1, U6.31 (VDS)
unnamed: R14.2, U6.48 (nSHDN)

Notes on the sheet:
DRV8323 / 栅极驱动 / 内置LDO
输出轴编码器
A相电流
MCU / 控制与采样
C相上管
三相 MOSFET 功率级
母线电压
B相上管
通过电阻选择灌电流大小 10ma 连AGND 30ma 18K连AGND 60ma 75K连AGND 120ma 高阻态 260ma 75K连DVDD 570ma 75K连DVDD 1000ma 直连DVDD
SPC的GND从Q6源极取参考
B相下管
B相电流
5V 600ma输出能力
A相上管
堵转电流5A，额定电流1.6A I^2*R=5*5*0.012=0.3W 放大倍率20，中点为1.65V。1.65V的量程为 1.65/0.012 = 6.8A 采样电阻暂定为12mΩ，如果未来不够，可以切换为10Ω。
A相下管
电机端编码器
24V分压，母线电压检测
选择放大器增益，这里选择20倍放大，R7,R8不焊接 5倍 连AGND 10倍 47K 20倍 高阻态 40倍 3.3V直连
差分滤波电路
6XPWM模式
高电平校准放大器输入，设备内部有下拉
只支持CAN2.0
3.3V，30MA输出，本工程不使用该电源
0.06V 连AGND 0.13V 18K连AGND 0.26V 75K连AGND 0.6V 1.13V 1.88V 禁用 直连3.3V
VDRAIN检测线从MOSFET上管漏极独立走
高电平使能，使能前保证拉低CAL
根据实际情况决定是否焊接
C相下管
故障指示
CAL拉高高校准运放，1OOUS之后拉低，正常采样。

Board: 4 copper layers, 41.2 x 42.5 mm, 75 parts (20 on the bottom side), 58 nets.
